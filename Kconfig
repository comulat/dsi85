## Kconfig
```kconfig
config DRM_BRIDGE_DSI85
	tristate "DSI85 DSI-to-LVDS bridge"
	depends on OF
	select DRM_KMS_HELPER
	select REGMAP_I2C
	help
	  Support for the DSI85 DSI-to-LVDS-bridge.
```
